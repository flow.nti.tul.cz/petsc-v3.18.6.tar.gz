#
#   This mechanism was created by Shashi Aithal
#
-chem chem_meth_ethanol.inp
-thermo therm_meth_ethanol.dat

-monitor_temp
#Temp in kelvin
-Tini 1500
##pressure is in N/m2
-pressure 5.065e5
-initial_species CH4,C2H5OH,O2,N2
#initial concentration in moles
-initial_mole 1,0.1,2.3,8.648


-ts_arkimex_fully_implicit
-ts_max_snes_failures -1
-ts_adapt_monitor
-ts_arkimex_type 4
-ts_max_time 2.0e-3
-ts_adapt_type basic
-ts_monitor_envelope

# the chemistry dictates reasonable bounds on the timestep
-ts_adapt_dt_max 1e-4
-ts_adapt_dt_min 1e-9

-snes_max_it 10

-pc_type lu
